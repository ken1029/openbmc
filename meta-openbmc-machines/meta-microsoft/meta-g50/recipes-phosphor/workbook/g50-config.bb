SUMMARY = "G50 board wiring"
DESCRIPTION = "Board wiring information for the G50 system."
HOMEPAGE = "git://csibmc@csibmc.visualstudio.com:22/G50/_git/skeleton;protocol=ssh;"
PR = "r1"

SRCREV = "51a033f9f7d581bd8ea503cf6ce3604e782f1028"
inherit config-in-skeleton
inherit obmc-phosphor-license
