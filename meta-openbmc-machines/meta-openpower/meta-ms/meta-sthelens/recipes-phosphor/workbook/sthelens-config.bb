SUMMARY = "StHelens board wiring"
DESCRIPTION = "Board wiring information for the StHelens system."
HOMEPAGE = "https://github.com/JasonLuo701/skeleton"
PR = "r1"

SRCREV = "fcc2944204061d68f46a62f4a3a4cbaaf0a75e11"
inherit config-in-skeleton
inherit obmc-phosphor-license
