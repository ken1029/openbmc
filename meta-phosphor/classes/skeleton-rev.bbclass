SRCREV ?= "5e9ea5ba488f8314b9d160a1bdcb8e30c6c12c41"
FOXCONN_BRANCH ?= "foxconn-g2"
SKELETON_URI ?= "git://github.com/foxconn-bmc-ks/skeleton;protocol=git;branch=${FOXCONN_BRANCH}"
