KBRANCH ?= "dev-4.4"
LINUX_VERSION ?= "4.4"
SRCREV="3ea11ef8f6c85abcf68d049782f9eeab5d82d07d"
require linux-obmc.inc
