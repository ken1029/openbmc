LINUX_VERSION ?= "4.7"
SRCREV="dda028547a62737dbfa91e42c3d00b0270ee43f4"

require common/recipes-kernel/linux/linux-obmc.inc
